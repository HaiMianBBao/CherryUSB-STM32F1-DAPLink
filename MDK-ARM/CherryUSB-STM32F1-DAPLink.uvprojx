# Keil uVision project CherryUSB-STM32F1-DAPLink.uvprojx, settings and files
target CherryUSB-STM32F1-DAPLink (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CherryUSB-STM32F1-DAPLink +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../RTT;../CherryUSB-Daplink/CherryUSB/class/cdc;../CherryUSB-Daplink/CherryUSB/common;../CherryUSB-Daplink/CherryUSB/core;../CherryUSB-Daplink/port/stm32f1;../CherryUSB-Daplink/ring_buffer;../CherryUSB-Daplink/src/DAP/Include;../../CherryUSB-STM32F1-DAPLink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../CherryUSB-Daplink/CherryUSB/class/cdc/: usbd_cdc.c
    ../CherryUSB-Daplink/CherryUSB/core/: usbd_core.c
    ../CherryUSB-Daplink/CherryUSB/port/fsdev/: usb_dc_fsdev.c
    ../CherryUSB-Daplink/ring_buffer/: ringbuffer.c
    ../CherryUSB-Daplink/src/: dap_main.c dap_process.c winusb.c
    ../CherryUSB-Daplink/port/stm32f1/: port_core.c
    ../CherryUSB-Daplink/src/DAP/Source/: DAP.c JTAG_DP.c SW_DP.c
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 5.6.0
